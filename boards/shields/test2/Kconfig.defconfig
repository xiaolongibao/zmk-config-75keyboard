## boards/shields/test2/Kconfig.defconfig
```kconfig
if SHIELD_TEST2

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "test2"

endif
```
